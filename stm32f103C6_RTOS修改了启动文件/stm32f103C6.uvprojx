# Keil uVision project stm32f103C6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103C6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEBUG_ENABLE_SEMIHOST,STM32F10X_LD
  c include: .\Library\inc;.\Interrupt;.\Boot;.\Src;.\FreeRTOS\porting;.\FreeRTOS\Source;.\FreeRTOS\Source\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group boot
    ./Boot/: core_cm3.c startup_stm32f10x_ld_modify.s
  group lib
    ./Library/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c misc.c
  group interrupt
    ./Interrupt/: stm32f10x_it.c
  group src
    ./Src/: main.c system_stm32f10x.c
  group FreeRTOS/Core
    ./FreeRTOS/Source/src/: tasks.c list.c
  group FreeRTOS/Portable
    ./FreeRTOS/porting/: port.c heap_4.c
