# Keil uVision project STM32F103C6.uvprojx, settings and files
target STM32F103C6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEBUG_ENABLE_SEMIHOST,STM32F10X_LD
  c include: .\Boot;.\Interrupt;.\Library;.\Library\inc;.\Src;.\UCOS\cpu;.\UCOS\lib;.\UCOS\portable;.\UCOS\source
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group boot
    ./Boot/: core_cm3.c startup_stm32f10x_ld.s
  group library
    ./Library/: system_stm32f10x.c
    ./Library/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c
  group interrupt
    ./Interrupt/: stm32f10x_it.c
  group src
    ./Src/: main.c
  group uCOS-III/Source
    ./UCOS/source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS/Lib
    ./UCOS/lib/: lib_math.c lib_mem.c lib_mem_a.asm lib_str.c lib_ascii.c
  group uCOS/Cpu
    ./UCOS/cpu/: cpu_a.asm cpu_c.c cpu_core.c
  group uCOS/Portable
    ./UCOS/portable/: os_cpu_c.c os_cpu_a.s os_app_hooks.c bsp.c
